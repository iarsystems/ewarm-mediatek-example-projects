# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BL_DEBUG; MOD_CFG_FOTA_DISABLE_OS; MOD_CFG_FOTA_DISABLE_CLI; BL_FOTA_DEBUG; CFG_SUPPORT_SMNT_PROTO=2
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: inc; ..\..\..\LinkIt SDK 01_17\driver\chip\mt7687\inc; ..\..\..\LinkIt SDK 01_17\driver\chip\inc; ..\..\..\LinkIt SDK 01_17\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\LinkIt SDK 01_17\driver\chip\mt7687\src\common\include; ..\..\..\LinkIt SDK 01_17\kernel\service\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\fota\inc\76x7; ..\..\..\LinkIt SDK 01_17\middleware\MTK\fota\inc; ..\..\..\LinkIt SDK 01_17\driver\board\mt76x7_hdk\bootloader\src\mt7687; ..\..\..\LinkIt SDK 01_17\driver\board\mt76x7_hdk\util\inc; ..\..\..\LinkIt SDK 01_17\driver\board\mt76x7_hdk\wifi\inc; ..\..\..\LinkIt SDK 01_17\kernel\rtos\FreeRTOS\Source\include; ..\..\..\LinkIt SDK 01_17\driver\board\mt76x7_hdk\ept\inc; ..\..\..\LinkIt SDK 01_17\middleware\third_party\lzma_decoder\inc; ..\..\..\LinkIt SDK 01_17\driver\board\mt76x7_hdk\external_flash\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: bootloader.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: config/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MT7687F Mediatek MT7687F
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkKeepSymbols: __isr_vector
  ILINK.IlinkIcfFile: config/mtk7687_flash.icf
  group cmsis
    src/: startup_mt7687.s system_mt7687.c
  group driver
    ../../../LinkIt SDK 01_17/driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
    ../../../LinkIt SDK 01_17/driver/chip/mt7687/src/common/: dma.c flash_sfc.c gpt.c hal_gpio_7687.c hal_pinmux.c low_hal_gpio.c nvic.c pinmux.c sfc.c spi_flash.c timer.c top.c uart.c
    ../../../LinkIt SDK 01_17/driver/chip/mt7687/src/: hal_aes.c hal_cache.c hal_cache_internal.c hal_flash.c hal_gpio.c hal_gpt.c hal_log.c hal_nvic.c hal_nvic_internal.c hal_sha.c hal_uart.c
    ../../../LinkIt SDK 01_17/driver/board/mt76x7_hdk/bootloader/src/mt7687/: hw_uart.c main.c
  group ept
    ../../../LinkIt SDK 01_17/driver/board/mt76x7_hdk/ept/src/: bsp_gpio_ept_config.c
    src/: ept_eint_var.c ept_gpio_var.c
  group fota
    ../../../LinkIt SDK 01_17/middleware/MTK/fota/src/76x7/: fota_76x7.c fota_config.c fota_port.c
  group lib
    ../../../LinkIt SDK 01_17/driver/chip/mt7687/lib/: libhal_protected_CM4_IAR.a
  group lzma_decoder
    ../../../LinkIt SDK 01_17/middleware/third_party/lzma_decoder/src/: lzma_decode_interface.c lzma_decoder.c
