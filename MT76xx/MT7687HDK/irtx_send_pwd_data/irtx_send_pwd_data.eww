<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/irtx_send_pwd_data.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>irtx_send_pwd_data</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>irtx_send_pwd_data</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
