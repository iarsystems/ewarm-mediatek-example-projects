<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/gpio_configure_pull_state.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>gpio_configure_pull_state</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gpio_configure_pull_state</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
