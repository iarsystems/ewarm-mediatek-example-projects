<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/des_encrypt_decrypt_data.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Rebuild All Configs</name>
      <member>
        <project>des_encrypt_decrypt_data</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>des_encrypt_decrypt_data</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
