<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/gpc_capture_pulses_polling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>gpc_capture_pulses_polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gpc_capture_pulses_polling</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
