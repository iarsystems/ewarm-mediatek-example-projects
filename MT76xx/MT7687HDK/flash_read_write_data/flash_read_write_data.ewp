# IAR project flash_read_write_data.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MT7687F Mediatek MT7687F
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; $PROJ_DIR$; ..\..\..\LinkIt SDK 01_17\driver\chip\inc; ..\..\..\LinkIt SDK 01_17\driver\chip\mt7687\inc; ..\..\..\LinkIt SDK 01_17\driver\chip\mt7687\src\common\include; ..\..\..\LinkIt SDK 01_17\driver\CMSIS\Device\MTK\mt7687\Include; ..\..\..\LinkIt SDK 01_17\common; ..\..\..\LinkIt SDK 01_17\driver\board\mt76x7_hdk\ept\inc; ..\..\..\LinkIt SDK 01_17\driver\board\mt76x7_hdk\external_flash\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: flash_read_write_data.bin
  ILINK.IlinkOutputFile: adc_get_data_polling.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: ../local/flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\LinkIt SDK 01_17\driver\chip\mt7687\lib\libhal_protected_CM4_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ./: main.c
  group cmsis
    ../../../LinkIt SDK 01_17/driver/CMSIS/Device/MTK/mt7687/Source/: startup_mt7687.s
    ../local/: system_mt7687.c
  group driver
    ../../../LinkIt SDK 01_17/driver/board/mt76x7_hdk/external_flash/src/: bsp_flash_config.c
    ../../../LinkIt SDK 01_17/driver/chip/mt7687/src/common/: dma.c flash_sfc.c gpt.c hal_gpio_7687.c hal_pinmux.c low_hal_gpio.c nvic.c pinmux.c sfc.c spi_flash.c timer.c top.c uart.c
    ../../../LinkIt SDK 01_17/driver/chip/mt7687/src/: hal_adc.c hal_cache.c hal_cache_internal.c hal_flash.c hal_gpio.c hal_gpt.c hal_log.c hal_nvic.c hal_nvic_internal.c hal_uart.c
  group lib
    ../../../LinkIt SDK 01_17/driver/chip/mt7687/lib/: libhal_core_CM4_IAR.a
