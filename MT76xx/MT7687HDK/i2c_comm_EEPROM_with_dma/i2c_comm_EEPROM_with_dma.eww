<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/i2c_comm_EEPROM_with_dma.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>i2c_comm_EEPROM_with_dma</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>i2c_comm_EEPROM_with_dma</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
