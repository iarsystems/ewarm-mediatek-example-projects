<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/gdma_transfer_data_interrupt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Rebuild All Configs</name>
      <member>
        <project>gdma_transfer_data_interrupt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gdma_transfer_data_interrupt</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
