<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/irrx_receive_pwd_data.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>irrx_receive_pwd_data</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>irrx_receive_pwd_data</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
