<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/adc_get_data_polling.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Rebuild All Configs</name>
      <member>
        <project>adc_get_data_polling</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>adc_get_data_polling</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
