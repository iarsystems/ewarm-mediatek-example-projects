<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/g2d_overlay_layer.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>g2d_overlay_layer</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>g2d_overlay_layer</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
