<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/sleep_manager_power_mode.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>sleep_manager_power_mode</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sleep_manager_power_mode</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
