# IAR project sleep_manager_power_mode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MT2523G Mediatek MT2523G
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=2523; MTK_DEVELOPMENT_BOARD_HDK; MTK_SMART_BATTERY_ENABLE; MTK_NVDM_ENABLE; __BT_DEBUG__
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; inc; ..\..\..\LinkIt SDK 01_17\driver\CMSIS\Include; ..\..\..\LinkIt SDK 01_17\driver\CMSIS\Device\MTK\mt2523\Include; ..\..\..\LinkIt SDK 01_17\driver\chip\inc; ..\..\..\LinkIt SDK 01_17\driver\chip\mt2523\inc; ..\..\..\LinkIt SDK 01_17\kernel\service\inc; ..\..\..\LinkIt SDK 01_17\kernel\rtos\FreeRTOS\Source\include; ..\..\..\LinkIt SDK 01_17\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\LinkIt SDK 01_17\driver\board\component\common; ..\..\..\LinkIt SDK 01_17\driver\board\component\lcm\ST7789H2; inc\bt_audio; inc\bt_audio\sink; ..\..\..\LinkIt SDK 01_17\middleware\MTK\bluetooth\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\nvdm\inc; inc\graphicLib; ..\..\..\LinkIt SDK 01_17\middleware\MTK\atci\inc; inc\gnss_screen; inc\pxp_screen; inc\sensor_demo; inc\watch_face; ..\..\..\LinkIt SDK 01_17\driver\board\mt25x3_hdk\lcd; ..\..\..\LinkIt SDK 01_17\middleware\MTK\sensor_subsys\inc; ..\..\..\LinkIt SDK 01_17\driver\board\component\mems\inc; ..\..\..\LinkIt SDK 01_17\driver\board\component\mems\src\libyas533\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\gnss\inc; ..\..\..\LinkIt SDK 01_17\driver\board\mt25x3_hdk\backlight; ..\..\..\LinkIt SDK 01_17\driver\board\mt25x3_hdk\keypad\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\audio\inc; ..\..\..\LinkIt SDK 01_17\driver\board\component\biosensor\mt2511\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\nvdm\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\nvdm\src\nvdm_internal.h; ..\..\..\LinkIt SDK 01_17\middleware\MTK\nvdm\src\portable; ..\..\..\LinkIt SDK 01_17\driver\board\mt25x3_hdk\bt_codec\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\gnss\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\battery_management\port\mt2523\lib\fuelgauge\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\battery_management\port\mt2523\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\battery_management\inc; ..\..\..\LinkIt SDK 01_17\driver\board\component\touch_panel\ctp_goodix_gt9xxx\gt9137; ..\..\..\LinkIt SDK 01_17\driver\board\component\bt_codec\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\audio\inc; ..\..\..\LinkIt SDK 01_17\driver\board\component\touch_panel\common\inc; ..\..\..\LinkIt SDK 01_17\driver\board\mt25x3_hdk\touch_panel\gt9137; ..\..\..\LinkIt SDK 01_17\driver\board\mt25x3_hdk\touch_panel\it7258; ..\..\..\LinkIt SDK 01_17\driver\board\component\touch_panel\ctp_ite_it7xxx\it7258; ..\..\..\LinkIt SDK 01_17\driver\board\component\biosensor\mt2511\inc; ..\..\..\LinkIt SDK 01_17\driver\board\component\biosensor\mt2511\module\default; ..\..\..\LinkIt SDK 01_17\driver\board\component\biosensor\mt2511\module\everlight; ..\..\..\LinkIt SDK 01_17\middleware\MTK\sensor_subsys\fusion_algo\common\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\sensor_subsys\fusion_algo\heart_rate\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\sensor_subsys\fusion_algo\heart_rate_variability\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\sensor_subsys\fusion_algo\ppg_control\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\nvdm\inc_core; ..\..\..\LinkIt SDK 01_17\middleware\third_party\kiss_fft; ..\..\..\LinkIt SDK 01_17\middleware\MTK\port_service\inc; ..\..\..\LinkIt SDK 01_17\middleware\MTK\usb\inc; ..\..\..\LinkIt SDK 01_17\driver\board\mt25x3_hdk\ept\inc; ..\..\..\LinkIt SDK 01_17\middleware\third_party\kiss_fft; ..\..\..\LinkIt SDK 01_17\middleware\third_party\mbedtls\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: inc
  OBJCOPY.OOCOutputFile: $CONFIG_NAME$.bin
  ILINK.IlinkOutputFile: audio_play_1k_tone.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: ../local/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group app
    src/: ept_eint_var.c ept_gpio_var.c main.c sys_init.c
  group battery_management_core
    ../../../LinkIt SDK 01_17/middleware/MTK/battery_management/port/mt2523/src/: battery_management_core.c battery_management_driver.c battery_management_meter.c
  group board
    ../../../LinkIt SDK 01_17/driver/board/component/touch_panel/common/src/: bsp_ctp.c ctp.c ctp_i2c.c
    ../../../LinkIt SDK 01_17/driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../LinkIt SDK 01_17/driver/board/component/touch_panel/ctp_goodix_gt9xxx/gt9137/: ctp_goodix_gt9xxx.c
    ../../../LinkIt SDK 01_17/driver/board/component/touch_panel/ctp_ite_it7xxx/it7258/: ctp_ite_it7xxx.c ctp_ite_it7xxx_download.c
    ../../../LinkIt SDK 01_17/driver/board/mt25x3_hdk/gnss/: gnss_config.c
    ../../../LinkIt SDK 01_17/driver/board/mt25x3_hdk/keypad/src/: keypad_custom.c
    ../../../LinkIt SDK 01_17/driver/board/component/lcm/ST7789H2/: lcd.c
    ../../../LinkIt SDK 01_17/driver/board/component/lcm/RM69032/: lcd_RM69032.c
    ../../../LinkIt SDK 01_17/driver/board/mt25x3_hdk/backlight/: mt25x3_hdk_backlight.c
    ../../../LinkIt SDK 01_17/driver/board/mt25x3_hdk/lcd/: mt25x3_hdk_lcd.c
    ../../../LinkIt SDK 01_17/driver/board/mt25x3_hdk/touch_panel/gt9137/: touch_panel_custom_goodix.c
    ../../../LinkIt SDK 01_17/driver/board/mt25x3_hdk/touch_panel/it7258/: touch_panel_custom_ite.c
  group cmsis
    ../local/: startup_mt2523.s system_mt2523.c
  group driver
    ../../../LinkIt SDK 01_17/driver/chip/mt2523/src/: hal_accdet.c hal_accdet_internal.c hal_adc.c hal_audio.c hal_audio_custom.c hal_audio_enhancement.c hal_audio_fw_interface.c hal_audio_fw_slt.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_internal_vm.c hal_audio_low_power.c hal_audio_post_processing.c hal_audio_test.c hal_bsi.c hal_cache.c hal_cache_internal.c hal_charger.c hal_clock_internal.c hal_dac.c hal_dcm.c hal_dcxo.c hal_display_color.c hal_display_color_internal.c hal_display_dsi.c hal_display_dsi_internal.c hal_display_lcd.c hal_display_lcd_internal.c hal_display_pwm.c hal_display_pwm_internal.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_g2d.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_i2s.c hal_i2s_internal.c hal_i2s_internal_pcm_route.c hal_isink.c hal_keypad.c hal_keypad_internal.c hal_keypad_powerkey_internal.c hal_log.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pmu_wrap_interface.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c hal_usb.c hal_usb_phy.c hal_wdt.c hal_wdt_internal.c hal_wdt_retention.c hal_weak.c
  group kernel
    ../../../LinkIt SDK 01_17/kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../LinkIt SDK 01_17/kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../LinkIt SDK 01_17/kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../LinkIt SDK 01_17/kernel/rtos/FreeRTOS/Source/portable/IAR/mt2523/: port_tick.c
  group kservice
    ../../../LinkIt SDK 01_17/kernel/service/lib/: libkservice_CM4_MT2523_IAR.a
    ../../../LinkIt SDK 01_17/kernel/service/src/: memory_regions.c os_port_callback.c
  group lib
    ../../../LinkIt SDK 01_17/middleware/MTK/bluetooth/lib/: libbt_driver_2523_iar.a libbt_iar.a
    ../../../LinkIt SDK 01_17/middleware/MTK/battery_management/port/mt2523/lib/: libfgauge_IAR.a
    ../../../LinkIt SDK 01_17/driver/chip/mt2523/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group nvdm
    ../../../LinkIt SDK 01_17/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../LinkIt SDK 01_17/middleware/MTK/nvdm/src/: nvdm_port.c
