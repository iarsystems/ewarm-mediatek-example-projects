<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/trng_generate_random_data.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>trng_generate_random_data</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>trng_generate_random_data</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
