<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/pwm_generate_waveform.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>pwm_generate_waveform</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>pwm_generate_waveform</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
