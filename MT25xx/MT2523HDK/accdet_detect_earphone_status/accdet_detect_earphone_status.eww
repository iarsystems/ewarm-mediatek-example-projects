<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/accdet_detect_earphone_status.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>accdet_detect_earphone_status</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>accdet_detect_earphone_status</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
