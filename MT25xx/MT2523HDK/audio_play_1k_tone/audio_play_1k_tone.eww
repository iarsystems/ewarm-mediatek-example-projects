<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/audio_play_1k_tone.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>audio_play_1k_tone</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>audio_play_1k_tone</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
