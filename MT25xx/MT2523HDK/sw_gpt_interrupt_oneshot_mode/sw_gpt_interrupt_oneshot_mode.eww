<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/sw_gpt_interrupt_oneshot_mode.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>sw_gpt_interrupt_oneshot_mode</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sw_gpt_interrupt_oneshot_mode</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
