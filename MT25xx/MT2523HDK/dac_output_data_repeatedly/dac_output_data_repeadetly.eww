<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/dac_output_data_repeadetly.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>dac_output_data_repeadetly</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>dac_output_data_repeadetly</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
