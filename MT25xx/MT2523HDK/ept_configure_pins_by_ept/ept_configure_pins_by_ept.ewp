# IAR project ept_configure_pins_by_ept.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MT2523G Mediatek MT2523G
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=2523
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: inc; ..\..\..\LinkIt SDK 01_17\driver\CMSIS\Include; ..\..\..\LinkIt SDK 01_17\driver\CMSIS\Device\MTK\mt2523\Include; ..\..\..\LinkIt SDK 01_17\driver\chip\inc; ..\..\..\LinkIt SDK 01_17\driver\chip\mt2523\inc; ..\..\..\LinkIt SDK 01_17\driver\board\mt25x3_hdk\ept\inc; ..\..\..\LinkIt SDK 01_17\kernel\service\inc; ..\..\..\LinkIt SDK 01_17\kernel\rtos\FreeRTOS\Source\include; ..\..\..\LinkIt SDK 01_17\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: $CONFIG_NAME$.bin
  ILINK.IlinkOutputFile: audio_play_1k_tone.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: ../local/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; MTK_DEBUG_LEVEL_INFO; PRODUCT_VERSION=2523
  ICCARM.CCOptLevel: 3
  group app
    src/: main.c
  group cmsis
    ../local/: startup_mt2523.s system_mt2523.c
  group driver
    ../../../LinkIt SDK 01_17/driver/board/mt25x3_hdk/ept/src/: bsp_gpio_ept_config.c
    src/: ept_eint_var.c ept_gpio_var.c
    ../../../LinkIt SDK 01_17/driver/chip/mt2523/src/: hal_audio.c hal_audio_custom.c hal_audio_enhancement.c hal_audio_fw_interface.c hal_audio_internal_afe.c hal_audio_internal_pcm.c hal_audio_internal_pcm2way.c hal_audio_internal_service.c hal_audio_internal_vm.c hal_audio_low_power.c hal_audio_post_processing.c hal_audio_test.c hal_cache.c hal_cache_internal.c hal_clock_internal.c hal_dvfs.c hal_dvfs_internal.c hal_dvfs_internal_vcore.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2c_pmic.c hal_log.c hal_misc.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_auxadc.c hal_pmu_internal.c hal_pmu_wrap_interface.c hal_pwm.c hal_uart.c hal_uart_internal.c hal_uart_internal_platform.c
    ../../../LinkIt SDK 01_17/kernel/service/src/: memory_regions.c
  group lib
    ../../../LinkIt SDK 01_17/driver/chip/mt2523/lib/: libhal_core_CM4_IAR.a
