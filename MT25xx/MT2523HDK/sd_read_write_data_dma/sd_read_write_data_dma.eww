<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/sd_read_write_data_dma.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>sd_read_write_data_dma</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sd_read_write_data_dma</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
