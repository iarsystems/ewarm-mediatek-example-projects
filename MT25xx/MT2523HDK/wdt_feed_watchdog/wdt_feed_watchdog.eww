<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/wdt_feed_watchdog.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>wdt_feed_watchdog</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>wdt_feed_watchdog</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
