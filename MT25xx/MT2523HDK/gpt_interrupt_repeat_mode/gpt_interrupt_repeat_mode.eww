<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/gpt_interrupt_repeat_mode.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>gpt_interrupt_repeat_mode</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>gpt_interrupt_repeat_mode</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
